# Keil uVision project ATC30.uvprojx, settings and files
target mart (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATC30GG
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ..\ATC30GG.bin ..\Outputs\ATC30GG.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,USE_STM3210C_EVAL,HXZ_RELEASE_VERSION
  c include: ..\CMSIS;..\Library\inc;..\Library\STM32_USB-FS-Device_Driver\inc;..\Kernel;..\BSP\Basic;..\BSP;..\BSP\IWDG;..\BSP\Led;..\BSP\Key;..\BSP\ADC;..\App\Debug;..\App\SelfCheck;..\App\Voltage;..\App\ATC30;..\App;..\BSP\uart;..\App\Task;..\App\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c
  group STLibrary
    ../Library/src/: misc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c
  group Kernel
    ../Kernel/: rdelay.c rtime.c rstring.c rsystem.c
  group Bsp_Basic
    ../BSP/Basic/: uart.c nvic.c
    ../BSP/: bsp.c 5110LCD.c stmflash.c 74hc595.c remote.c GPIO.c
    ../BSP/uart/: systest.c
    ../BSP/Key/: key.c
  group Bsp_Led
    ../BSP/IWDG/: iwdg.c
    ../BSP/: led.c
  group App_Task
    ../App/Task/: task.c
  group App_LCD
    ../App/: LCD.c
  group APP_MODE
    ../App/: MODE.c
  group App
    ../App/: stm32f10x_it.c main.c
  group ReleaseNote
    ../: ReleaseNote.txt
